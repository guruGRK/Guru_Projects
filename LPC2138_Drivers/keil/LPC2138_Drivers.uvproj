# Keil uVision project LPC2138_Drivers.uvproj, settings and files
target LPC2138_Drivers (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2138_Drivers
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group startup
    ./: Startup.s
